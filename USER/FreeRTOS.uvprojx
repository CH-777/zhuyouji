# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\oled;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\FreeModbus\modbus\include;..\FreeModbus\modbus\rtu;..\FreeModbus\port;..\bsp\adc;..\bsp\encoder;..\bsp\GPIO;..\bsp\SD;..\easylogger\inc;..\easylogger\plugins\flash;..\APP\input_gpio;..\APP\oil;..\APP\output_gpio
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group BSP
    ../bsp/adc/: adc.c
    ../bsp/encoder/: encoder.c
    ../bsp/GPIO/: gpio.c
    ../bsp/SD/: sd.c spi.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: README.TXT
  group FreeModbus
    ../FreeModbus/modbus/: mb.c
    ../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../FreeModbus/port/: user_mb_app.c
    ../FreeModbus/port/freertos/: portevent.c portserial.c porttimer.c
  group EsayLogger
    ../easylogger/port/: elog_port.c
    ../easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group APP
    ../APP/input_gpio/: input_gpio.c
    ../APP/output_gpio/: output_gpio.c
    ../APP/oil/: oil.c
